# Repository marshalltaylorSFE/KiCad-Library

## KiCad design Test Projects/Teensy_test_layout.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8: Hole; MountingHole_3mm

Notes on the sheet:
Logic
Knob connections
Power
MIDI and other jacks
Knobs
LEDs

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C43, C44, C45: 10u; TantalC_SizeB_EIA-3528_Reflow
JACK12: POWER_JACKPTH; SparkFun-Connectors-POWER_JACK_PTH
JMP1: 3Jumper; SF-3way-open
P1: CONN_01X02; Pin_Header_Straight_1x02
P31, P36, P56, P57, P59, P60, P61: CONN_01X01; TestHole
P58: VUU; Pin_Header_Straight_1x01
P62: UGND; Pin_Header_Straight_1x01
P63, P90: CONN_01X01; Pin_Header_Straight_1x01
R1, R3, R19: 11.3K; R_0603
R2, R4, R20: 34K; R_0603
R5: 11.5K; R_0603
R6: 18.7K; R_0603
U1, U2, U4, U33: LDO-adj-4term; SF-SOT-223
U3: Teensy_3.2; Teensy_3.2_Route

Connections:
+1V8: C2.1, R1.1, U1.2 (OUT), U1.4 (OUT); also elsewhere on the board
+3V3: JMP1.2; also elsewhere on the board
+3V3_REG: C8.1, JMP1.3, R5.1, U4.2 (OUT), U4.4 (OUT); also elsewhere on the board
+3V3_TOUT: JMP1.1, U3.36 (3.3V), U3.40 (3.3V), U3.43 (3.3V)
+5V: C5.1, P31.1, R3.1, U2.2 (OUT), U2.4 (OUT), U3.34 (Vin); also elsewhere on the board
unnamed: C3.1, R1.2, R2.1, U1.1 (ADJ)
unnamed: C6.1, R3.2, R4.1, U2.1 (ADJ)
unnamed: C9.1, R5.2, R6.1, U4.1 (ADJ)
unnamed: C45.1, R19.2, R20.1, U33.1 (ADJ)
UGND: C43.2, C44.2, C45.2, P59.1, P60.1, P61.1, P62.1, R20.2
VUU: C44.1, P56.1, P57.1, P58.1, R19.1, U33.2 (OUT), U33.4 (OUT)
VUUIN: C43.1, P63.1, U33.3 (IN)

Parts:
C15, C16, C42: C; C_0603
C69, C70, C71: 22p; C_0603
JMP8, JMP9: 2Jumper; SF-2way-open
P3: COLS0; Pin_Header_Straight_1x08
P4: COLS1; Pin_Header_Straight_1x08
P32: PIN8; TestHole
P33: SIO2; TestHole
P34: ~HOLD~/SIO3; TestHole
P35: PIN37; TestHole
P37: PIN31; TestHole
P100: SPI_MOSI; TestHole
P101: SPI_MISO; TestHole
P102: SPI_SCK; TestHole
R8, R9: 2.2K; R_0603
R98, R99, R100: 50; R_0603
R101, R102: 4.7k; R_0603
ROWS1: CONN_01X04; Pin_Header_Straight_1x04
U3: Teensy_3.2; Teensy_3.2_Route
U6: SF-MicroSD-12term; SF-MICRO-SD
U7, U8: SF-74HC595; SF-SOIC-16
U32: SPI_MEMORY_SOIC8; SF-SOIC-8

Connections:
!LED_RST: U3.26 (26,RX2,A15); also elsewhere on the board
+3V3: C15.1, C16.1, C42.1, JMP8.1, JMP9.1, R8.1, R9.1, R101.1, R102.1, U6.4 (VCC), U7.10 (SRCLR), U7.16 (VCC), U8.10 (SRCLR), U8.16 (VCC), U32.8 (VCC); also elsewhere on the board
A: U3.27 (27,A16); also elsewhere on the board
B: U3.28 (28,A17); also elsewhere on the board
BCLK: U3.16 (16,Touch,SCL0,A2), U7.11 (SRCLK), U8.11 (SRCLK)
BLATCH: U3.24, U7.12 (RCLK), U8.12 (RCLK)
BOE: U3.25 (25,PWM,Touch), U7.13 (G), U8.13 (G)
BSER: U3.17 (17,Touch,SDA0,A3), U7.14 (SER)
C: U3.29 (29,SCL1,A18); also elsewhere on the board
D: U3.20 (20,PWM,CS,A6); also elsewhere on the board
I2S_BCLK: U3.9 (9,PWM,CS,RX2); also elsewhere on the board
I2S_DIN0: U3.22 (22,PWM,Touch,A8); also elsewhere on the board
I2S_DIN1: U3.15 (15,Touch,CS,A1); also elsewhere on the board
I2S_DOUT0: U3.13 (13,SCK,LED); also elsewhere on the board
I2S_DOUT1: U3.30 (30,SDA1,A19); also elsewhere on the board
I2S_LRCLK: U3.23 (23,PWM,Touch,A9); also elsewhere on the board
I2S_MCLK: U3.11 (11,DOUT); also elsewhere on the board
KA0: U3.44 (A10); also elsewhere on the board
KA1: U3.45 (A11); also elsewhere on the board
KA2: U3.46 (A12); also elsewhere on the board
KA3: U3.47 (A13); also elsewhere on the board
LED_LATCH: U3.32 (32,PWM,Touch); also elsewhere on the board
LED_OE: U3.33 (33,Touch); also elsewhere on the board
unnamed: JMP8.2, P33.1, U32.3 (SIO2)
unnamed: JMP9.2, P34.1, U32.7 (~HOLD~/SIO3)
unnamed: P3.1, U7.15 (QA)
unnamed: P3.2, U7.1 (QB)
unnamed: P3.3, U7.2 (QC)
unnamed: P3.4, U7.3 (QD)
unnamed: P3.5, U7.4 (QE)
unnamed: P3.6, U7.5 (QF)
unnamed: P3.7, U7.6 (QG)
unnamed: P3.8, U7.7 (QH)
unnamed: P4.1, U8.15 (QA)
unnamed: P4.2, U8.1 (QB)
unnamed: P4.3, U8.2 (QC)
unnamed: P4.4, U8.3 (QD)
unnamed: P4.5, U8.4 (QE)
unnamed: P4.6, U8.5 (QF)
unnamed: P4.7, U8.6 (QG)
unnamed: P4.8, U8.7 (QH)
unnamed: P32.1, U3.8 (8,DIN,TX3)
unnamed: P35.1, U3.37 (A14,DAC)
unnamed: P37.1, U3.31 (31,TX2,A20)
unnamed: R101.2, U6.8 (RSV)
unnamed: R102.2, U6.1 (NC)
unnamed: U7.9 (~QH), U8.14 (SER)
PORT-RX: U3.0 (0,Touch,RX1); also elsewhere on the board
PORT-TX: U3.1 (1,Touch,TX1); also elsewhere on the board
RAM_CS: U3.6 (6,PWM), U32.1 (~CS)
ROW1: ROWS1.1, U3.2
ROW2: ROWS1.2, U3.3 (3,PWM,TX)
ROW3: ROWS1.3, U3.4 (4,PWM,RX)
ROW4: ROWS1.4, U3.5 (5,PWM,TX1)
SCL0: R8.2, U3.19 (19,Touch,SCL0,A5); also elsewhere on the board
SDA0: R9.2, U3.18 (18,Touch,SDA0,A4); also elsewhere on the board
SD_CS: U3.10 (10,PWM,CS,TX2), U6.2 (CS)
SPI_MISO: C69.1, P101.1, R100.2, U3.12 (12,DIN), U6.7 (DO)
SPI_MISO_SRC: R100.1, U32.2 (SO/SIO1)
SPI_MOSI: C70.1, P100.1, R99.2, U6.3 (DI), U32.5 (SI/SIO0); also elsewhere on the board
SPI_MOSI_SRC: R99.1, U3.7 (7,DOUT,RX3)
SPI_SCK: C71.1, P102.1, R98.2, U6.5 (SCK), U32.6 (SCK); also elsewhere on the board
SPI_SCK_SRC: R98.1, U3.14 (14,SCK,A0)

Notes on the sheet:
I2C Assignment- I2C0 codec config, misc devices (expansion) SPI SD card RAM/ROM LEDs

Parts:
C18, C60: 68uF; TantalC_SizeC_EIA-6032_Reflow
C55, C61: 1uF; C_0603
P13, P14, P15, P16, P17, P18, P19, P20, P40, P41, P42, P43, P44, P45, P46, P47, P48, P49, P50, P51, P52, P53, P54, P55: CONN_01X08; Pin_Header_Straight_1x08
P82, P83, P84, P85, P86, P103, P106, P107: CONN_01X01; PTH_LUG_.05
R95, R97: 1; R_0603

Connections:
+3V3: R95.2; also elsewhere on the board
+5V: R97.2; also elsewhere on the board
K1: P13.1; also elsewhere on the board
K2: P13.2; also elsewhere on the board
K3: P13.3; also elsewhere on the board
K4: P13.4; also elsewhere on the board
K5: P13.5; also elsewhere on the board
K6: P13.6; also elsewhere on the board
K7: P13.7; also elsewhere on the board
K8: P13.8; also elsewhere on the board
K9: P14.1; also elsewhere on the board
K10: P14.2; also elsewhere on the board
K11: P14.3; also elsewhere on the board
K12: P14.4; also elsewhere on the board
K13: P14.5; also elsewhere on the board
K14: P14.6; also elsewhere on the board
K15: P14.7; also elsewhere on the board
K16: P14.8; also elsewhere on the board
K17: P15.1; also elsewhere on the board
K18: P15.2; also elsewhere on the board
K19: P15.3; also elsewhere on the board
K20: P15.4; also elsewhere on the board
K21: P15.5; also elsewhere on the board
K22: P15.6; also elsewhere on the board
K23: P15.7; also elsewhere on the board
K24: P15.8; also elsewhere on the board
K25: P16.1; also elsewhere on the board
K26: P16.2; also elsewhere on the board
K27: P16.3; also elsewhere on the board
K28: P16.4; also elsewhere on the board
K29: P16.5; also elsewhere on the board
K30: P16.6; also elsewhere on the board
K31: P16.7; also elsewhere on the board
K32: P16.8; also elsewhere on the board
K33: P17.1; also elsewhere on the board
K34: P17.2; also elsewhere on the board
K35: P17.3; also elsewhere on the board
K36: P17.4; also elsewhere on the board
K37: P17.5; also elsewhere on the board
K38: P17.6; also elsewhere on the board
K39: P17.7; also elsewhere on the board
K40: P17.8; also elsewhere on the board
K41: P18.1; also elsewhere on the board
K42: P18.2; also elsewhere on the board
K43: P18.3; also elsewhere on the board
K44: P18.4; also elsewhere on the board
K45: P18.5; also elsewhere on the board
K46: P18.6; also elsewhere on the board
K47: P18.7; also elsewhere on the board
K48: P18.8; also elsewhere on the board
K49: P19.1; also elsewhere on the board
K50: P19.2; also elsewhere on the board
K51: P19.3; also elsewhere on the board
K52: P19.4; also elsewhere on the board
K53: P19.5; also elsewhere on the board
K54: P19.6; also elsewhere on the board
K55: P19.7; also elsewhere on the board
K56: P19.8; also elsewhere on the board
K57: P20.1; also elsewhere on the board
K58: P20.2; also elsewhere on the board
K59: P20.3; also elsewhere on the board
K60: P20.4; also elsewhere on the board
K61: P20.5; also elsewhere on the board
K62: P20.6; also elsewhere on the board
K63: P20.7; also elsewhere on the board
K64: P20.8; also elsewhere on the board
KGND: P48.1, P48.2, P48.3, P48.4, P48.5, P48.6, P48.7, P48.8, P49.1, P49.2, P49.3, P49.4, P49.5, P49.6, P49.7, P49.8, P50.1, P50.2, P50.3, P50.4, P50.5, P50.6, P50.7, P50.8, P51.1, P51.2, P51.3, P51.4, P51.5, P51.6, P51.7, P51.8, P85.1
KGND2: P52.1, P52.2, P52.3, P52.4, P52.5, P52.6, P52.7, P52.8, P53.1, P53.2, P53.3, P53.4, P53.5, P53.6, P53.7, P53.8, P54.1, P54.2, P54.3, P54.4, P54.5, P54.6, P54.7, P54.8, P55.1, P55.2, P55.3, P55.4, P55.5, P55.6, P55.7, P55.8, P86.1
unnamed: C18.1, C55.1, P103.1, R95.1
unnamed: C60.1, C61.1, P106.1, R97.1
VKK: P40.1, P40.2, P40.3, P40.4, P40.5, P40.6, P40.7, P40.8, P41.1, P41.2, P41.3, P41.4, P41.5, P41.6, P41.7, P41.8, P42.1, P42.2, P42.3, P42.4, P42.5, P42.6, P42.7, P42.8, P43.1, P43.2, P43.3, P43.4, P43.5, P43.6, P43.7, P43.8, P82.1
VKK2: P44.1, P44.2, P44.3, P44.4, P44.5, P44.6, P44.7, P44.8, P45.1, P45.2, P45.3, P45.4, P45.5, P45.6, P45.7, P45.8, P46.1, P46.2, P46.3, P46.4, P46.5, P46.6, P46.7, P46.8, P47.1, P47.2, P47.3, P47.4, P47.5, P47.6, P47.7, P47.8, P83.1

Parts:
C17, C54: D; TantalC_SizeB_EIA-3528_Reflow
JACK1, JACK2, JACK3: DIN-5; SF-DIN-5
JACK4, JACK5, JACK6, JACK7, JACK8, JACK9, JACK10, JACK11: TRS_6term; SF-Neutrik-Jack-6-term
JMP18: THRU; SF-2way-open
JMP19, JMP20: IN2; SF-2way-open
P5, P6, P7, P8, P9, P10, P11, P12: CONN_01X06; Pin_Header_Straight_1x06
P73: IN2TTL; TestHole
R10, R11, R12, R13, R14, R15, R29, R30: 220; R_0603
U9, U10: SF-74x125; SF-SOT-23-5
U11, U34: 2N168; SF-SMD-8

Connections:
+5V: R10.1, R11.1, R15.1, R30.1, U9.5 (VCC), U10.5 (VCC), U11.8 (VCC), U34.8 (VCC); also elsewhere on the board
CHASSIS: JACK1.6, JACK1.7, JACK2.6, JACK2.7, JACK3.6, JACK3.7
unnamed: C17.1, JACK3.5, U11.3 (C)
unnamed: C17.2, JACK3.4, R14.1
unnamed: C54.1, JMP20.1, U34.3 (C)
unnamed: C54.2, JMP19.1, R29.2
unnamed: JACK1.4, JMP19.2, R10.2
unnamed: JACK1.5, JMP20.2, R12.1
unnamed: JACK2.4, R11.2
unnamed: JACK2.5, R13.1
unnamed: JACK4.G, P5.4
unnamed: JACK4.R, P5.2
unnamed: JACK4.RN, P5.5
unnamed: JACK4.S, P5.3
unnamed: JACK4.T, P5.1
unnamed: JACK4.TN, P5.6
unnamed: JACK5.G, P6.4
unnamed: JACK5.R, P6.2
unnamed: JACK5.RN, P6.5
unnamed: JACK5.S, P6.3
unnamed: JACK5.T, P6.1
unnamed: JACK5.TN, P6.6
unnamed: JACK6.G, P7.4
unnamed: JACK6.R, P7.2
unnamed: JACK6.RN, P7.5
unnamed: JACK6.S, P7.3
unnamed: JACK6.T, P7.1
unnamed: JACK6.TN, P7.6
unnamed: JACK7.G, P8.4
unnamed: JACK7.R, P8.2
unnamed: JACK7.RN, P8.5
unnamed: JACK7.S, P8.3
unnamed: JACK7.T, P8.1
unnamed: JACK7.TN, P8.6
unnamed: JACK8.G, P9.4
unnamed: JACK8.R, P9.2
unnamed: JACK8.RN, P9.5
unnamed: JACK8.S, P9.3
unnamed: JACK8.T, P9.1
unnamed: JACK8.TN, P9.6
unnamed: JACK9.G, P10.4
unnamed: JACK9.R, P10.2
unnamed: JACK9.RN, P10.5
unnamed: JACK9.S, P10.3
unnamed: JACK9.T, P10.1
unnamed: JACK9.TN, P10.6
unnamed: JACK10.G, P11.4
unnamed: JACK10.R, P11.2
unnamed: JACK10.RN, P11.5
unnamed: JACK10.S, P11.3
unnamed: JACK10.T, P11.1
unnamed: JACK10.TN, P11.6
unnamed: JACK11.G, P12.4
unnamed: JACK11.R, P12.2
unnamed: JACK11.RN, P12.5
unnamed: JACK11.S, P12.3
unnamed: JACK11.T, P12.1
unnamed: JACK11.TN, P12.6
unnamed: JMP18.2, U9.2 (A)
unnamed: P73.1, R30.2, U34.6 (Vo)
unnamed: R12.2, U9.4 (Y)
unnamed: R13.2, U10.4 (Y)
unnamed: R14.2, U11.2 (A)
unnamed: R29.1, U34.2 (A)
PORT-RX: JMP18.1, R15.2, U11.6 (Vo); also elsewhere on the board
PORT-TX: U10.2 (A); also elsewhere on the board

Parts:
C19, C20, C21, C22, C23, C24, C25, C26, C27, C28: 1u; C_0603
P21: CONN_01X05; Pin_Header_Straight_1x05
P89: CONN_01X04; Pin_Header_Straight_1x04
P108: CONN_01X01; PTH_LUG_.05
U13, U14, U15, U16, U17, U18, U19, U20, U21, U22: SF-4052; SF-SOIC-16

Connections:
A: P89.1, U13.10 (A), U14.10 (A), U15.10 (A), U16.10 (A), U17.10 (A), U18.10 (A), U19.10 (A), U20.10 (A); also elsewhere on the board
B: P89.2, U13.9 (B), U14.9 (B), U15.9 (B), U16.9 (B), U17.9 (B), U18.9 (B), U19.9 (B), U20.9 (B); also elsewhere on the board
C: P89.3, U21.10 (A), U22.10 (A); also elsewhere on the board
D: P89.4, U21.9 (B), U22.9 (B); also elsewhere on the board
EN: P21.5, U13.6 (Inh), U14.6 (Inh), U15.6 (Inh), U16.6 (Inh), U17.6 (Inh), U18.6 (Inh), U19.6 (Inh), U20.6 (Inh), U21.6 (Inh), U22.6 (Inh)
K1: U13.12 (X0); also elsewhere on the board
K2: U13.14 (X1); also elsewhere on the board
K3: U13.15 (X2); also elsewhere on the board
K4: U13.11 (X3); also elsewhere on the board
K5: U13.1 (Y0); also elsewhere on the board
K6: U13.5 (Y1); also elsewhere on the board
K7: U13.2 (Y2); also elsewhere on the board
K8: U13.4 (Y3); also elsewhere on the board
K9: U14.12 (X0); also elsewhere on the board
K10: U14.14 (X1); also elsewhere on the board
K11: U14.15 (X2); also elsewhere on the board
K12: U14.11 (X3); also elsewhere on the board
K13: U14.1 (Y0); also elsewhere on the board
K14: U14.5 (Y1); also elsewhere on the board
K15: U14.2 (Y2); also elsewhere on the board
K16: U14.4 (Y3); also elsewhere on the board
K17: U15.12 (X0); also elsewhere on the board
K18: U15.14 (X1); also elsewhere on the board
K19: U15.15 (X2); also elsewhere on the board
K20: U15.11 (X3); also elsewhere on the board
K21: U15.1 (Y0); also elsewhere on the board
K22: U15.5 (Y1); also elsewhere on the board
K23: U15.2 (Y2); also elsewhere on the board
K24: U15.4 (Y3); also elsewhere on the board
K25: U16.12 (X0); also elsewhere on the board
K26: U16.14 (X1); also elsewhere on the board
K27: U16.15 (X2); also elsewhere on the board
K28: U16.11 (X3); also elsewhere on the board
K29: U16.1 (Y0); also elsewhere on the board
K30: U16.5 (Y1); also elsewhere on the board
K31: U16.2 (Y2); also elsewhere on the board
K32: U16.4 (Y3); also elsewhere on the board
K33: U17.12 (X0); also elsewhere on the board
K34: U17.14 (X1); also elsewhere on the board
K35: U17.15 (X2); also elsewhere on the board
K36: U17.11 (X3); also elsewhere on the board
K37: U17.1 (Y0); also elsewhere on the board
K38: U17.5 (Y1); also elsewhere on the board
K39: U17.2 (Y2); also elsewhere on the board
K40: U17.4 (Y3); also elsewhere on the board
K41: U18.12 (X0); also elsewhere on the board
K42: U18.14 (X1); also elsewhere on the board
K43: U18.15 (X2); also elsewhere on the board
K44: U18.11 (X3); also elsewhere on the board
K45: U18.1 (Y0); also elsewhere on the board
K46: U18.5 (Y1); also elsewhere on the board
K47: U18.2 (Y2); also elsewhere on the board
K48: U18.4 (Y3); also elsewhere on the board
K49: U19.12 (X0); also elsewhere on the board
K50: U19.14 (X1); also elsewhere on the board
K51: U19.15 (X2); also elsewhere on the board
K52: U19.11 (X3); also elsewhere on the board
K53: U19.1 (Y0); also elsewhere on the board
K54: U19.5 (Y1); also elsewhere on the board
K55: U19.2 (Y2); also elsewhere on the board
K56: U19.4 (Y3); also elsewhere on the board
K57: U20.12 (X0); also elsewhere on the board
K58: U20.14 (X1); also elsewhere on the board
K59: U20.15 (X2); also elsewhere on the board
K60: U20.11 (X3); also elsewhere on the board
K61: U20.1 (Y0); also elsewhere on the board
K62: U20.5 (Y1); also elsewhere on the board
K63: U20.2 (Y2); also elsewhere on the board
K64: U20.4 (Y3); also elsewhere on the board
KA0: P21.1, U21.13 (X); also elsewhere on the board
KA1: P21.2, U21.3 (Y); also elsewhere on the board
KA2: P21.3, U22.13 (X); also elsewhere on the board
KA3: P21.4, U22.3 (Y); also elsewhere on the board
KOUT1: U13.13 (X), U21.12 (X0)
KOUT2: U13.3 (Y), U21.14 (X1)
KOUT3: U14.13 (X), U21.15 (X2)
KOUT4: U14.3 (Y), U21.11 (X3)
KOUT5: U15.13 (X), U21.1 (Y0)
KOUT6: U15.3 (Y), U21.5 (Y1)
KOUT7: U16.13 (X), U21.2 (Y2)
KOUT8: U16.3 (Y), U21.4 (Y3)
KOUT9: U17.13 (X), U22.12 (X0)
KOUT10: U17.3 (Y), U22.14 (X1)
KOUT11: U18.13 (X), U22.15 (X2)
KOUT12: U18.3 (Y), U22.11 (X3)
KOUT13: U19.13 (X), U22.1 (Y0)
KOUT14: U19.3 (Y), U22.5 (Y1)
KOUT15: U20.13 (X), U22.2 (Y2)
KOUT16: U20.3 (Y), U22.4 (Y3)
VDD: C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, P108.1, U13.16 (VDD), U14.16 (VDD), U15.16 (VDD), U16.16 (VDD), U17.16 (VDD), U18.16 (VDD), U19.16 (VDD), U20.16 (VDD), U21.16 (VDD), U22.16 (VDD)
