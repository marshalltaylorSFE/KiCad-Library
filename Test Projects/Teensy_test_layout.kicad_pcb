# Repository marshalltaylorSFE/KiCad-Library (continued)

## KiCad design Test Projects/Teensy_test_layout.kicad_pcb (continued)

Parts:
C29, C30, C31, C32, C33, C34, C35, C36: C; C_0603
P22, P23, P24, P25, P26, P27, P28, P29, P74, P75, P76, P77, P78, P79, P80, P81: CONN_01X08; Pin_Header_Straight_1x08
P87, P88: CONN_01X01; PTH_LUG_.05
R17, R18: 4.7k; R_0603
R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94: 470; R_0603
U23, U24, U25, U26, U27, U28, U29, U30: SF-74HC595; SF-SOIC-16

Connections:
!LED_RST: R18.1, U23.10 (SRCLR), U24.10 (SRCLR), U25.10 (SRCLR), U26.10 (SRCLR), U27.10 (SRCLR), U28.10 (SRCLR), U29.10 (SRCLR), U30.10 (SRCLR); also elsewhere on the board
+5V: C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, R17.1, U23.16 (VCC), U24.16 (VCC), U25.16 (VCC), U26.16 (VCC), U27.16 (VCC), U28.16 (VCC), U29.16 (VCC), U30.16 (VCC); also elsewhere on the board
LED_BUS: P74.1, P74.2, P74.3, P74.4, P74.5, P74.6, P74.7, P74.8, P75.1, P75.2, P75.3, P75.4, P75.5, P75.6, P75.7, P75.8, P76.1, P76.2, P76.3, P76.4, P76.5, P76.6, P76.7, P76.8, P77.1, P77.2, P77.3, P77.4, P77.5, P77.6, P77.7, P77.8, P78.1, P78.2, P78.3, P78.4, P78.5, P78.6, P78.7, P78.8, P79.1, P79.2, P79.3, P79.4, P79.5, P79.6, P79.7, P79.8, P80.1, P80.2, P80.3, P80.4, P80.5, P80.6, P80.7, P80.8, P81.1, P81.2, P81.3, P81.4, P81.5, P81.6, P81.7, P81.8, P87.1, P88.1
LED_LATCH: U23.12 (RCLK), U24.12 (RCLK), U25.12 (RCLK), U26.12 (RCLK), U27.12 (RCLK), U28.12 (RCLK), U29.12 (RCLK), U30.12 (RCLK); also elsewhere on the board
LED_OE: R17.2, U23.13 (G), U24.13 (G), U25.13 (G), U26.13 (G), U27.13 (G), U28.13 (G), U29.13 (G), U30.13 (G); also elsewhere on the board
unnamed: P22.1, R31.1
unnamed: P22.2, R33.1
unnamed: P22.3, R35.1
unnamed: P22.4, R37.1
unnamed: P22.5, R39.1
unnamed: P22.6, R41.1
unnamed: P22.7, R43.1
unnamed: P22.8, R45.1
unnamed: P23.1, R47.1
unnamed: P23.2, R49.1
unnamed: P23.3, R51.1
unnamed: P23.4, R53.1
unnamed: P23.5, R55.1
unnamed: P23.6, R57.1
unnamed: P23.7, R59.1
unnamed: P23.8, R61.1
unnamed: P24.1, R32.1
unnamed: P24.2, R34.1
unnamed: P24.3, R36.1
unnamed: P24.4, R38.1
unnamed: P24.5, R40.1
unnamed: P24.6, R42.1
unnamed: P24.7, R44.1
unnamed: P24.8, R46.1
unnamed: P25.1, R48.1
unnamed: P25.2, R50.1
unnamed: P25.3, R52.1
unnamed: P25.4, R54.1
unnamed: P25.5, R56.1
unnamed: P25.6, R58.1
unnamed: P25.7, R60.1
unnamed: P25.8, R62.1
unnamed: P26.1, R63.1
unnamed: P26.2, R65.1
unnamed: P26.3, R67.1
unnamed: P26.4, R69.1
unnamed: P26.5, R71.1
unnamed: P26.6, R73.1
unnamed: P26.7, R75.1
unnamed: P26.8, R77.1
unnamed: P27.1, R79.1
unnamed: P27.2, R81.1
unnamed: P27.3, R83.1
unnamed: P27.4, R85.1
unnamed: P27.5, R87.1
unnamed: P27.6, R89.1
unnamed: P27.7, R91.1
unnamed: P27.8, R93.1
unnamed: P28.1, R64.1
unnamed: P28.2, R66.1
unnamed: P28.3, R68.1
unnamed: P28.4, R70.1
unnamed: P28.5, R72.1
unnamed: P28.6, R74.1
unnamed: P28.7, R76.1
unnamed: P28.8, R78.1
unnamed: P29.1, R80.1
unnamed: P29.2, R82.1
unnamed: P29.3, R84.1
unnamed: P29.4, R86.1
unnamed: P29.5, R88.1
unnamed: P29.6, R90.1
unnamed: P29.7, R92.1
unnamed: P29.8, R94.1
unnamed: R31.2, U23.15 (QA)
unnamed: R32.2, U25.15 (QA)
unnamed: R33.2, U23.1 (QB)
unnamed: R34.2, U25.1 (QB)
unnamed: R35.2, U23.2 (QC)
unnamed: R36.2, U25.2 (QC)
unnamed: R37.2, U23.3 (QD)
unnamed: R38.2, U25.3 (QD)
unnamed: R39.2, U23.4 (QE)
unnamed: R40.2, U25.4 (QE)
unnamed: R41.2, U23.5 (QF)
unnamed: R42.2, U25.5 (QF)
unnamed: R43.2, U23.6 (QG)
unnamed: R44.2, U25.6 (QG)
unnamed: R45.2, U23.7 (QH)
unnamed: R46.2, U25.7 (QH)
unnamed: R47.2, U24.15 (QA)
unnamed: R48.2, U26.15 (QA)
unnamed: R49.2, U24.1 (QB)
unnamed: R50.2, U26.1 (QB)
unnamed: R51.2, U24.2 (QC)
unnamed: R52.2, U26.2 (QC)
unnamed: R53.2, U24.3 (QD)
unnamed: R54.2, U26.3 (QD)
unnamed: R55.2, U24.4 (QE)
unnamed: R56.2, U26.4 (QE)
unnamed: R57.2, U24.5 (QF)
unnamed: R58.2, U26.5 (QF)
unnamed: R59.2, U24.6 (QG)
unnamed: R60.2, U26.6 (QG)
unnamed: R61.2, U24.7 (QH)
unnamed: R62.2, U26.7 (QH)
unnamed: R63.2, U27.15 (QA)
unnamed: R64.2, U29.15 (QA)
unnamed: R65.2, U27.1 (QB)
unnamed: R66.2, U29.1 (QB)
unnamed: R67.2, U27.2 (QC)
unnamed: R68.2, U29.2 (QC)
unnamed: R69.2, U27.3 (QD)
unnamed: R70.2, U29.3 (QD)
unnamed: R71.2, U27.4 (QE)
unnamed: R72.2, U29.4 (QE)
unnamed: R73.2, U27.5 (QF)
unnamed: R74.2, U29.5 (QF)
unnamed: R75.2, U27.6 (QG)
unnamed: R76.2, U29.6 (QG)
unnamed: R77.2, U27.7 (QH)
unnamed: R78.2, U29.7 (QH)
unnamed: R79.2, U28.15 (QA)
unnamed: R80.2, U30.15 (QA)
unnamed: R81.2, U28.1 (QB)
unnamed: R82.2, U30.1 (QB)
unnamed: R83.2, U28.2 (QC)
unnamed: R84.2, U30.2 (QC)
unnamed: R85.2, U28.3 (QD)
unnamed: R86.2, U30.3 (QD)
unnamed: R87.2, U28.4 (QE)
unnamed: R88.2, U30.4 (QE)
unnamed: R89.2, U28.5 (QF)
unnamed: R90.2, U30.5 (QF)
unnamed: R91.2, U28.6 (QG)
unnamed: R92.2, U30.6 (QG)
unnamed: R93.2, U28.7 (QH)
unnamed: R94.2, U30.7 (QH)
unnamed: U23.9 (~QH), U24.14 (SER)
unnamed: U24.9 (~QH), U25.14 (SER)
unnamed: U25.9 (~QH), U26.14 (SER)
unnamed: U26.9 (~QH), U27.14 (SER)
unnamed: U27.9 (~QH), U28.14 (SER)
unnamed: U28.9 (~QH), U29.14 (SER)
unnamed: U29.9 (~QH), U30.14 (SER)
SPI_MOSI: U23.14 (SER); also elsewhere on the board
SPI_SCK: U23.11 (SRCLK), U24.11 (SRCLK), U25.11 (SRCLK), U26.11 (SRCLK), U27.11 (SRCLK), U28.11 (SRCLK), U29.11 (SRCLK), U30.11 (SRCLK); also elsewhere on the board

Parts:
C10, C11, C12, C13, C14, C37, C38, C39, C40, C41: 0.1uF; C_0603
C46, C47, C48, C49, C50, C51, C52, C53: 2.2u; TantalC_SizeB_EIA-3528_Reflow
C62, C63, C64, C65, C66, C67, C68: 22p; C_0603
JMP2, JMP3, JMP6, JMP7, JMP10, JMP11, JMP12, JMP13, JMP14, JMP15, JMP16, JMP17, JMP21, JMP22, JMP23, JMP24, JMP25, JMP26, JMP27, JMP28, JMP29: 2Jumper; SF-2way-open
JMP4, JMP5: 3Jumper; SF-3way-open
P2, P30: CONN_01X03; Pin_Header_Straight_1x03
P38, P39: CONN_01X06; Pin_Header_Straight_1x06
P64: DIN1; TestHole
P65: DOUT1; TestHole
P66: SDA0_ISO; TestHole
P67: SCL0_ISO; TestHole
P68: MCLK_ISO; TestHole
P69: BCLK_ISO; TestHole
P70: LRCLK_ISO; TestHole
P71: DIN0; TestHole
P72: DOUT0; TestHole
P91: SDA0; TestHole
P92: SCL0; TestHole
P93: MCLK; TestHole
P94: BCLK; TestHole
P95: LRCLK; TestHole
P96: DIN1_ISO; TestHole
P97: DOUT1_ISO; TestHole
P98: DIN0_ISO; TestHole
P99: DOUT0_ISO; TestHole
P109: SCL_ISO; TestHole
P110: SDA_ISO; TestHole
P111: SCL_ISO2; TestHole
P112: SDA_ISO2; TestHole
R7, R16: 1; R_0603
R21, R22, R23, R24, R25, R26, R27, R28: 100k; R_0603
U5, U31: SGTL5000; SF-QFN-32-NXP-SGTL5000

Connections:
1/2AINL: C46.2, JMP13.1, U5.14 (LINEINL)
1/2AINR: C47.2, JMP12.1, U5.13 (LINEINR)
1/2AOUTL: C48.2, JMP11.1, U5.12 (LINEOUTL)
1/2AOUTR: C49.2, JMP10.1, U5.11 (LINEOUTR)
3/4AINL: C50.2, JMP17.1, U31.14 (LINEINL)
3/4AINR: C51.2, JMP16.1, U31.13 (LINEINR)
3/4AOUTL: C52.2, JMP15.1, U31.12 (LINEOUTL)
3/4AOUTR: C53.2, JMP14.1, U31.11 (LINEOUTR)
+1V8: C11.1, C38.1, U5.30, U31.30; also elsewhere on the board
+3V3: C10.1, C39.1, JMP4.3, JMP5.3, R7.1, R16.1, U5.20, U31.20; also elsewhere on the board
BCLK_ISO: C65.1, JMP25.2, P69.1, U5.24 (BCLK), U31.24 (BCLK)
I2S_BCLK: JMP25.1, P94.1; also elsewhere on the board
I2S_DIN0: JMP2.1, P71.1; also elsewhere on the board
I2S_DIN0_ISO: C68.1, JMP2.2, P98.1, U5.26 (TX)
I2S_DIN1: JMP6.1, P64.1; also elsewhere on the board
I2S_DIN1_ISO: C62.1, JMP6.2, P96.1, U31.26 (TX)
I2S_DOUT0: C67.1, JMP3.1, P72.1; also elsewhere on the board
I2S_DOUT0_ISO: JMP3.2, P99.1, U5.25 (RX)
I2S_DOUT1: C63.1, JMP7.1, P65.1; also elsewhere on the board
I2S_DOUT1_ISO: JMP7.2, P97.1, U31.25 (RX)
I2S_LRCLK: JMP26.1, P95.1; also elsewhere on the board
I2S_MCLK: JMP24.1, P93.1; also elsewhere on the board
ISOGND12: C10.2, C11.2, C12.2, C13.2, C14.2, JMP4.1, JMP27.2, P38.2, P38.5, R21.2, R22.2, R23.2, R24.2, U5.1 (GND), U5.3 (GND), U5.7 (GND), U5.32 (MODE), U5.33 (GND)
ISOGND34: C37.2, C38.2, C39.2, C40.2, C41.2, JMP5.1, JMP28.2, P39.2, P39.5, R25.2, R26.2, R27.2, R28.2, U31.1 (GND), U31.3 (GND), U31.7 (GND), U31.32 (MODE), U31.33 (GND)
LRCLK_ISO: C64.1, JMP26.2, P70.1, U5.23 (LRCLK), U31.23 (LRCLK)
MCLK_ISO: C66.1, JMP24.2, P68.1, U5.21 (MCLK), U31.21 (MCLK)
unnamed: C12.1, C13.1, R7.2, U5.5
unnamed: C14.1, U5.10 (VAG)
unnamed: C37.1, U31.10 (VAG)
unnamed: C40.1, C41.1, R16.2, U31.5
unnamed: C46.1, JMP13.2, P38.1, R24.1
unnamed: C47.1, JMP12.2, P38.3, R23.1
unnamed: C48.1, JMP11.2, P38.4, R22.1
unnamed: C49.1, JMP10.2, P38.6, R21.1
unnamed: C50.1, JMP17.2, P39.1, R28.1
unnamed: C51.1, JMP16.2, P39.3, R27.1
unnamed: C52.1, JMP15.2, P39.4, R26.1
unnamed: C53.1, JMP14.2, P39.6, R25.1
unnamed: JMP4.2, U5.31 (ADDR)
unnamed: JMP5.2, U31.31 (ADDR)
unnamed: P2.1, U5.6 (HPL)
unnamed: P2.2, U5.2 (HPR)
unnamed: P2.3, U5.4 (HPVGND)
unnamed: P30.1, U31.6 (HPL)
unnamed: P30.2, U31.2 (HPR)
unnamed: P30.3, U31.4 (HPVGND)
SCL0: JMP29.1, P109.1; also elsewhere on the board
SCL12: JMP23.2, P67.1, U5.29 (SCL)
SCL34: JMP23.1, JMP29.2, P92.1, P111.1, U31.29 (SCL)
SDA0: JMP21.1, P110.1; also elsewhere on the board
SDA12: JMP22.2, P66.1, U5.27 (SDA)
SDA34: JMP21.2, JMP22.1, P91.1, P112.1, U31.27 (SDA)

Notes on the sheet:
Ports 1/2
Ports 3/4

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
Board: 2 copper layers, 254.0 x 127.0 mm, 368 parts (0 on the bottom side), 405 nets.

Other parts of the board:
C56, C57: 100u; c_elec_10x10.5
C58, C59: 1u; C_1206
P104, P105: CONN_01X01; TestHole
R96: 1; R_2512

Their connections:
+1V8: P104.1; also elsewhere on the board
+3V3_REG: P105.1; also elsewhere on the board

## KiCad design bkup/Test Projects/Teensy_test_layout.kicad_pcb

Notes on the sheet:
Logic
Analog
Power

Parts:
C1, C2, C3, C4, C5, C6: 10u; TantalC_SizeB_EIA-3528_HandSoldering
P1: CONN_01X02; Pin_Header_Straight_1x02
R1: 11.3K; R_0603
R2: 34K; R_0603
R3: 11.5K; R_0603
R4: 18.7K; R_0603
U1: Teensy_3.2; Teensy_3.2_Route
U2, U3: AP1117; SOT-323

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, P1.2, R2.2, R4.2, U1.39 (GND), U1.42 (GND), U1.50 (GND)
unnamed: C1.1, C4.1, P1.1, U2.3 (VI), U3.3 (VI)
unnamed: C2.1, R1.1, U1.34 (Vin), U2.2 (VO)
unnamed: C3.1, R1.2, R2.1, U2.1 (GND/ADJ)
unnamed: C5.1, R3.1, U3.2 (VO)
unnamed: C6.1, R3.2, R4.1, U3.1 (GND/ADJ)

Parts:
U1: Teensy_3.2; Teensy_3.2_Route

Parts:
U1: Teensy_3.2; Teensy_3.2_Route
U4: SGTL5000; QFN-32-NXP-SGTL5000

Connections:
unnamed: U1.18 (18,Touch,SDA0,A4), U4.27 (SDA)

Board: 2 copper layers, 15 parts (0 on the bottom side), 7 nets, no tracks yet.

## Commit log

2016-01-01 added md
2016-01-03 Libraries + test project
2016-01-03 Cleanup
2016-01-03 Tested a few layout sections
2016-01-04 Continued proto 1 layout
2016-01-05 Moved to 10x5 size
2016-01-19 unfolded connectors
2016-01-20 added second codec
2016-01-21 First major routing pass
2016-01-23 Post review with Byron
2016-01-25 Added holes, moved layout
2016-01-26 Routing, 15%
2016-01-27 layout
2016-01-29 more layout
2016-01-30 moar layout
2016-02-03 Finished artwork
2016-02-08 went to production
